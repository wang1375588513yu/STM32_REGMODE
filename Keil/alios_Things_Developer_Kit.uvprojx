# Keil uVision project alios_Things_Developer_Kit.uvprojx, settings and files
target alios_things (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L496VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: alios_Things_Developer_Kit
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L496xx,USE_HAL_DRIVER
  c include: ..\Source\Hardware\inc;..\Source\Kernel\Core\cmsis\Include;..\Source\System\inc;..\Source\User\inc;..\Source\Kernel\Hal_Lib\Inc;..\Source\standard\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ../Source/Kernel/Core/: startup_stm32l496xx.s
  group HALlib
    ../Source/Kernel/Hal_Lib/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_flash.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc.c stm32l4xx_hal_tim.c stm32l4xx_hal_uart.c stm32l4xx_hal_spi.c stm32l4xx_hal_dma.c stm32l4xx_hal_cortex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_lcd.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dsi.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_msp_template.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_timebase_tim_template.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c
  group Hardware
    ../Source/Hardware/src/: led.c delay.c timer.c
  group User
    ../Source/System/src/: main.c stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c
  group Standard
    ../Source/standard/src/: s_gpio.c s_iic.c s_spi.c s_usart.c
